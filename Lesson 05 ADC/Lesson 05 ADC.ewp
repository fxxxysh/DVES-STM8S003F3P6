# IAR project Lesson 05 ADC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\Tien\DVES\STM8\Project\Lesson 02 External Interrup\inc; E:\Tien\DVES\STM8\Project\Lesson 02 External Interrup\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Lesson 05 ADC.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_conf.h stm8s_it.c
    inc/: stm8s.h stm8s_exti.h
    src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c
