<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lesson 05 ADC.ewp</path>
    </project>
    <batchBuild />
</workspace>
