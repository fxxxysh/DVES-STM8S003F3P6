<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Blink LED\STM8-Lesson01-Blink LED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


